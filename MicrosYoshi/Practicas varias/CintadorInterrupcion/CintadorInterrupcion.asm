	;CONATDOR BINARIO GENERADO POR RETARDOS, CON TIMER Y POR ENCUESTA	

	.include "m8535def.inc"
	.cseg
	.org $0
	rjmp INICIO
	.org $09
	RJMP	T0_OUT
	.org	$15

INICIO: 
	LDI R16, LOW(RAMEND)
	OUT SPL, R16
	LDI R16, HIGH(RAMEND)
	OUT SPH, R16
	SER R16
	OUT DDRB, R16
	LDI R16,0b00000101
	OUT TIMSK, R16
	SET

LOOP: 
	RJMP LOOP

T0_OUT:
	CLI
	INC	R17
	OUT PORTB, R17
	SET
	RET

